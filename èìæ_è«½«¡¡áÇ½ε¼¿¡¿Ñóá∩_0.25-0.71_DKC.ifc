Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:28:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:28:30 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{6F7B76D9-1086-48CF-99DE-3EEB7D30EBD8}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:28:27 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:28:28 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:28:28 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 09591_0,71 м_цвет светло-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:09591_0,71 м_цвет светло-серебристый металлик:641964
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 09591_0,71 м_цвет светло-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09591; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09591/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09592_0,71 м_цвет белый, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:09592_0,71 м_цвет белый:641965
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 09592_0,71 м_цвет белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09592; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09592/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09593_0,71 м_цвет черный, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:09593_0,71 м_цвет черный:641966
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 09593_0,71 м_цвет черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09593; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09593/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09594_0,71 м_цвет темно-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:09594_0,71 м_цвет темно-серебристый металлик:641967
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 09594_0,71 м_цвет темно-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09594; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09594/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19521_0,25 м_цвет светло-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19521_0,25 м_цвет светло-серебристый металлик:641380
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 19521_0,25 м_цвет светло-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19521; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19521/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19522_0,25 м_цвет белый, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19522_0,25 м_цвет белый:641547
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 19522_0,25 м_цвет белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19522; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19522/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19523_0,25 м_цвет чёрный, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19523_0,25 м_цвет чёрный:641578
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 19523_0,25 м_цвет чёрный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19523; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19523/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19524_0,25 м_цвет темно-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19524_0,25 м_цвет темно-серебристый металлик:641606
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 19524_0,25 м_цвет темно-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19524; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19524/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19531_0,35 м_цвет светло-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19531_0,35 м_цвет светло-серебристый металлик:641761
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 19531_0,35 м_цвет светло-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19531; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19531/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19532_0,35 м_цвет белый, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19532_0,35 м_цвет белый:641763
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 19532_0,35 м_цвет белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19532; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19532/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19533_0,35 м_цвет чёрный, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19533_0,35 м_цвет чёрный:641764
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 19533_0,35 м_цвет чёрный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19533; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19533/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19534_0,35 м_цвет темно-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19534_0,35 м_цвет темно-серебристый металлик:641765
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 19534_0,35 м_цвет темно-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19534; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19534/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19551_0,5 м_цвет светло-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19551_0,5 м_цвет светло-серебристый металлик:641949
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 19551_0,5 м_цвет светло-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19551; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19551/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19552_0,5 м_цвет белый, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19552_0,5 м_цвет белый:641950
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 19552_0,5 м_цвет белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19552; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19552/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19553_0,5 м_цвет чёрный, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19553_0,5 м_цвет чёрный:641951
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 19553_0,5 м_цвет чёрный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19553; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19553/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 19554_0,5 м_цвет темно-серебристый металлик, КНС_КолоннаАлюминиевая_0.25-0.71_DKC:19554_0,5 м_цвет темно-серебристый металлик:641952
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 19554_0,5 м_цвет темно-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 19554; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/19554/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест вдали от стен. Условия монтажа: • колонна крепится к полу в 4 точках; • подвод кабелей с помощью гофрированных труб или в напольном кабель-канале ДКС; • колонны рекомендуется заземлять; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front".; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны
