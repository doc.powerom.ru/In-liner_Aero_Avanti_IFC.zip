Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:34:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:34:54 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B974B4EE-24D7-403D-AB02-6376CA473ECD}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:34:53 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:34:54 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:34:54 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2P+E IP44 16А 230В_Бежевая, КНС_РозеткаВСтену_DKC:2P+E IP44 16А 230В_Бежевая:545237
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 2P+E IP44 16А 230В_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение • для подключения бытовых приборов к сети 230 В. Особенности • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • подключение оргтехники, бытовых приборов и т. д.; • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 2P+E IP44 16А 230В_Белая, КНС_РозеткаВСтену_DKC:2P+E IP44 16А 230В_Белая:545240
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 2P+E IP44 16А 230В_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение • для подключения бытовых приборов к сети 230 В. Особенности • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • подключение оргтехники, бытовых приборов и т. д.; • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 2P+E IP44 16А 230В_Красная, КНС_РозеткаВСтену_DKC:2P+E IP44 16А 230В_Красная:545241
In: Этаж 01
Type - Material: DKC_Пластик_Красный
Pset_BuildingElementProxyCommon - Reference: 2P+E IP44 16А 230В_Красная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4401003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4401003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение • для подключения бытовых приборов к сети 230 В. Особенности • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • подключение оргтехники, бытовых приборов и т. д.; • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 2P+E IP44 16А 230В_Серая, КНС_РозеткаВСтену_DKC:2P+E IP44 16А 230В_Серая:545242
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 2P+E IP44 16А 230В_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение • для подключения бытовых приборов к сети 230 В. Особенности • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • подключение оргтехники, бытовых приборов и т. д.; • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 2P+E IP44 16А 230В_Черная, КНС_РозеткаВСтену_DKC:2P+E IP44 16А 230В_Черная:545362
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2P+E IP44 16А 230В_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402003; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402003/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение • для подключения бытовых приборов к сети 230 В. Особенности • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • подключение оргтехники, бытовых приборов и т. д.; • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: С крышкой_2P+E IP44 16А 230В_Бежевая, КНС_РозеткаВСтену_DKC:С крышкой_2P+E IP44 16А 230В_Бежевая:545593
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E IP44 16А 230В_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405013; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405013/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: С крышкой_2P+E IP44 16А 230В_Белая, КНС_РозеткаВСтену_DKC:С крышкой_2P+E IP44 16А 230В_Белая:545596
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E IP44 16А 230В_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400013; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400013/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: С крышкой_2P+E IP44 16А 230В_Серая, КНС_РозеткаВСтену_DKC:С крышкой_2P+E IP44 16А 230В_Серая:545597
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E IP44 16А 230В_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404013; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404013/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: С крышкой_2P+E IP44 16А 230В_Черная, КНС_РозеткаВСтену_DKC:С крышкой_2P+E IP44 16А 230В_Черная:545598
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E IP44 16А 230В_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402013; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402013/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
