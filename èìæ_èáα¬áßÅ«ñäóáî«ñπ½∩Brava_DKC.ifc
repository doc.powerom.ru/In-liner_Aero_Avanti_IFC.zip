Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:30:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:30:35 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{36E1D80A-AB3E-44A8-8BFD-4679C7D6D5E8}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:30:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:30:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:30:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Черный, КНС_КаркасПодДваМодуляBrava_DKC:Черный:645576
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F0000MB; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F0000MB/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC002554; Описание: Назначение: • монтаж электроустановочных изделий в пластиковые короба "In-liner Front", напольную башенку BUS, алюминиевые короба и колонны "In-liner Aero". Характеристики: • материал – АБС-пластик; • с двух внешних сторон расположены замки, предназначенные для соединения одинаковых каркасов в ряд и для использования под одной сплошной рамкой. Каркасы для разных серий ЭУИ между собой не соединяются, но монтироваться в ряд под одной рамкой.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны
