Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:21:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:21:43 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{94970BD6-EAB5-4ECD-8955-75C636AEF7F1}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:21:42 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:21:42 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:21:42 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: двойная бежевая, КНС_РозеткаТелефоннаяВСтену_DKC:двойная бежевая:681806
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: двойная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405314; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405314/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: двойная белая, КНС_РозеткаТелефоннаяВСтену_DKC:двойная белая:681808
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: двойная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400314; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400314/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: двойная серая, КНС_РозеткаТелефоннаяВСтену_DKC:двойная серая:681809
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: двойная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404314; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404314/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: двойная черная, КНС_РозеткаТелефоннаяВСтену_DKC:двойная черная:681811
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: двойная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402314; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402314/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: одинарная бежевая, КНС_РозеткаТелефоннаяВСтену_DKC:одинарная бежевая:681795
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: одинарная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405313; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405313/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: одинарная белая, КНС_РозеткаТелефоннаяВСтену_DKC:одинарная белая:681798
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: одинарная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400313; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400313/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: одинарная серая, КНС_РозеткаТелефоннаяВСтену_DKC:одинарная серая:681799
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: одинарная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404313; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404313/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: одинарная черная, КНС_РозеткаТелефоннаяВСтену_DKC:одинарная черная:681801
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: одинарная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402313; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402313/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телефонного кабеля к рабочему месту. Характеристики: • 6P6C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
