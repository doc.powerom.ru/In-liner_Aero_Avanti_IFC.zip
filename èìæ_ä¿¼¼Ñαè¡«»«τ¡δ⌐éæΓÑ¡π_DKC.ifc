Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:18:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:18:09 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{BD349055-C973-4FBC-8580-805D76732405}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:18:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:18:09 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:18:09 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Бежевый, КНС_ДиммерКнопочныйВСтену_DKC:Бежевый:679993
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: Бежевый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405343; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405343/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • управление освещенностью помещения. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • регулирование 3–120 Вт для LED ламп; • регулирование 3–220 Вт для ламп накаливания и галогенных ламп; • диммирование по переднему и заднему фронту; • выбор режима включения освещения (плавный пуск).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Белый, КНС_ДиммерКнопочныйВСтену_DKC:Белый:679996
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400343; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400343/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • управление освещенностью помещения. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • регулирование 3–120 Вт для LED ламп; • регулирование 3–220 Вт для ламп накаливания и галогенных ламп; • диммирование по переднему и заднему фронту; • выбор режима включения освещения (плавный пуск).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Серый, КНС_ДиммерКнопочныйВСтену_DKC:Серый:679997
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404343; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404343/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • управление освещенностью помещения. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • регулирование 3–120 Вт для LED ламп; • регулирование 3–220 Вт для ламп накаливания и галогенных ламп; • диммирование по переднему и заднему фронту; • выбор режима включения освещения (плавный пуск).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Черный, КНС_ДиммерКнопочныйВСтену_DKC:Черный:679999
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402343; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402343/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • управление освещенностью помещения. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • регулирование 3–120 Вт для LED ламп; • регулирование 3–220 Вт для ламп накаливания и галогенных ламп; • диммирование по переднему и заднему фронту; • выбор режима включения освещения (плавный пуск).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
