Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:44:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:44:38 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{DAB2AF7B-1364-4C41-829A-9B3BC9A2DADD}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:44:37 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:44:37 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:44:37 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 5е кат_Бежевая, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Бежевая:723176
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 5е кат_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405461; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405461/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Белая, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Белая:723177
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 5е кат_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400461; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400461/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Серая, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Серая:723178
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 5е кат_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404461; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404461/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Черная, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Черная:723179
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 5е кат_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402461; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402461/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Экранированная_Бежевая, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Экранированная_Бежевая:723153
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 5е кат_Экранированная_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405361; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405361/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Экранированная_Белая, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Экранированная_Белая:723156
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 5е кат_Экранированная_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400361; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400361/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Экранированная_Серая, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Экранированная_Серая:723157
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 5е кат_Экранированная_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404361; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404361/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 5е кат_Экранированная_Черная, КНС_РозеткаКомпьютернаяМодульная_DKC:5е кат_Экранированная_Черная:723159
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 5е кат_Экранированная_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402361; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402361/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Бежевая, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Бежевая:723164
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 6 кат_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405291; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405291/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Белая, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Белая:723166
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 6 кат_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400291; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400291/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Серая, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Серая:723167
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 6 кат_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404291; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404291/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Черная, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Черная:723169
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 6 кат_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402291; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402291/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Экранированная_Бежевая, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Экранированная_Бежевая:723180
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 6 кат_Экранированная_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405391; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405391/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Экранированная_Белая, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Экранированная_Белая:723181
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 6 кат_Экранированная_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400391; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400391/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Экранированная_Серая, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Экранированная_Серая:723182
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 6 кат_Экранированная_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404391; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404391/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6 кат_Экранированная_Черная, КНС_РозеткаКомпьютернаяМодульная_DKC:6 кат_Экранированная_Черная:723183
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 6 кат_Экранированная_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402391; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402391/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6А кат_Бежевая, КНС_РозеткаКомпьютернаяМодульная_DKC:6А кат_Бежевая:723188
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 6А кат_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405371; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405371/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6А кат_Белая, КНС_РозеткаКомпьютернаяМодульная_DKC:6А кат_Белая:723190
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 6А кат_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400371; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400371/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6А кат_Серая, КНС_РозеткаКомпьютернаяМодульная_DKC:6А кат_Серая:723191
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 6А кат_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404371; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404371/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 6А кат_Черная, КНС_РозеткаКомпьютернаяМодульная_DKC:6А кат_Черная:723193
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 6А кат_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402371; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402371/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары
