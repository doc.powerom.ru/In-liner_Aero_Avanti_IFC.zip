Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:35:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:35:52 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{72156540-D17C-4C60-9BE1-5192B22B5F19}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:35:51 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:35:51 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:35:51 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Оконечная_Бежевая, КНС_РозеткаТВВСтену_DKC:Оконечная_Бежевая:660418
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: Оконечная_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405503; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405503/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телевизионного кабеля к телевизору. Характеристики: • диапазон рабочих частот 4–2400 МГц; • затухание <7 дБ.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Оконечная_Белая, КНС_РозеткаТВВСтену_DKC:Оконечная_Белая:660421
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Оконечная_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400503; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400503/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телевизионного кабеля к телевизору. Характеристики: • диапазон рабочих частот 4–2400 МГц; • затухание <7 дБ.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Оконечная_Серая, КНС_РозеткаТВВСтену_DKC:Оконечная_Серая:660423
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: Оконечная_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404503; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404503/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телевизионного кабеля к телевизору. Характеристики: • диапазон рабочих частот 4–2400 МГц; • затухание <7 дБ.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Оконечная_Черная, КНС_РозеткаТВВСтену_DKC:Оконечная_Черная:660425
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Оконечная_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402503; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402503/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телевизионного кабеля к телевизору. Характеристики: • диапазон рабочих частот 4–2400 МГц; • затухание <7 дБ.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Проходная_Белая, КНС_РозеткаТВВСтену_DKC:Проходная_Белая:660429
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Проходная_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400513; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400513/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телевизионного кабеля к телевизору. Характеристики: • винтовые зажимы; • диапазон рабочих частот 4–2400 МГц; • затухание <1 дБ.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Проходная_Черная, КНС_РозеткаТВВСтену_DKC:Проходная_Черная:660432
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Проходная_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402513; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402513/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение телевизионного кабеля к телевизору. Характеристики: • винтовые зажимы; • диапазон рабочих частот 4–2400 МГц; • затухание <1 дБ.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
