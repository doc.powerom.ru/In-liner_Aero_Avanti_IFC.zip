Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:22:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:22:45 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{4B47B18F-5A50-4FD4-B20F-6CE9ACD4D613}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:22:44 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:22:44 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:22:44 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Серая, КНС_КоробкаДляНастенногоМонтажаДваМодуля_DKC:Серая:691539
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Стеклопластик
Pset_BuildingElementProxyCommon - Reference: Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4403932; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4403932/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000080; Описание: Назначение: • для монтажа на стены со степенью пылеи влагозащиты до IP 55. Характеристики: • материал – полипропилен; • температура монтажа от –25 до +60 °С; • используется при установке ЭУИ во влажных и запыленных помещениях.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
