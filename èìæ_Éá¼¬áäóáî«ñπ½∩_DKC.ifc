Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:31:22
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:31:22 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{D2C75C1A-B984-49F4-9344-566FF656BCD3}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:31:21 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:31:21 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:31:21 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ARTLEBEDEV_Бежевая, КНС_РамкаДваМодуля_DKC:ARTLEBEDEV_Бежевая:540255
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405902; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405902/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Белая, КНС_РамкаДваМодуля_DKC:ARTLEBEDEV_Белая:540495
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400902; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400902/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Серая, КНС_РамкаДваМодуля_DKC:ARTLEBEDEV_Серая:540541
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404902; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404902/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Черная, КНС_РамкаДваМодуля_DKC:ARTLEBEDEV_Черная:540549
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402902; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402902/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Алюминий_Серая, КНС_РамкаДваМодуля_DKC:Алюминий_Серая:540639
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_BuildingElementProxyCommon - Reference: Алюминий_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – алюминий; • фактура – браш.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Алюминий_Черная, КНС_РамкаДваМодуля_DKC:Алюминий_Черная:540642
In: Этаж 01
Type - Material: DKC_Алюминий_Черный
Pset_BuildingElementProxyCommon - Reference: Алюминий_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402832; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402832/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ Avanti (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – алюминий; • фактура – браш.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Дерево_Белая, КНС_РамкаДваМодуля_DKC:Дерево_Белая:540771
In: Этаж 01
Type - Material: DKC_Дерево_Белый
Pset_BuildingElementProxyCommon - Reference: Дерево_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400842; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400842/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – беленый дуб.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Дерево_Черная, КНС_РамкаДваМодуля_DKC:Дерево_Черная:540773
In: Этаж 01
Type - Material: DKC_Дерево_Черный
Pset_BuildingElementProxyCommon - Reference: Дерево_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402842; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402842/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – дерево венге.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Белая, КНС_РамкаДваМодуля_DKC:Металл_Белая:540836
In: Этаж 01
Type - Material: DKC_Металл_Белый
Pset_BuildingElementProxyCommon - Reference: Металл_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400852; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400852/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Графитовая, КНС_РамкаДваМодуля_DKC:Металл_Графитовая:540838
In: Этаж 01
Type - Material: DKC_Металл_Графит
Pset_BuildingElementProxyCommon - Reference: Металл_Графитовая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4407852; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4407852/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Золотая, КНС_РамкаДваМодуля_DKC:Металл_Золотая:540862
In: Этаж 01
Type - Material: DKC_Металл_Золотой
Pset_BuildingElementProxyCommon - Reference: Металл_Золотая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4408852; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4408852/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Никилированная, КНС_РамкаДваМодуля_DKC:Металл_Никилированная:555827
In: Этаж 01
Type - Material: DKC_Никель
Pset_BuildingElementProxyCommon - Reference: Металл_Никилированная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4409852; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4409852/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Темно-серая, КНС_РамкаДваМодуля_DKC:Металл_Темно-серая:540874
In: Этаж 01
Type - Material: DKC_Металл_Серый
Pset_BuildingElementProxyCommon - Reference: Металл_Темно-серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4403852; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4403852/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Черная, КНС_РамкаДваМодуля_DKC:Металл_Черная:540875
In: Этаж 01
Type - Material: DKC_Металл_Черный
Pset_BuildingElementProxyCommon - Reference: Металл_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402852; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402852/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Белая, КНС_РамкаДваМодуля_DKC:Натуральное стекло_Белая:541032
In: Этаж 01
Type - Material: DKC_Стекло_Белое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400822; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400822/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Светло-зеленая, КНС_РамкаДваМодуля_DKC:Натуральное стекло_Светло-зеленая:541035
In: Этаж 01
Type - Material: DKC_Стекло_Зеленое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Светло-зеленая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4406822; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4406822/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Светло-серая, КНС_РамкаДваМодуля_DKC:Натуральное стекло_Светло-серая:541036
In: Этаж 01
Type - Material: DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Светло-серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404822; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404822/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Черная, КНС_РамкаДваМодуля_DKC:Натуральное стекло_Черная:541037
In: Этаж 01
Type - Material: DKC_Стекло_Черное
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402822; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402822/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
