Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:32:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:32:50 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{1566AAF2-924D-429C-8FA6-B370A31C0205}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:32:49 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:32:49 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:32:49 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ARTLEBEDEV_Бежевая, КНС_РамкаЧетыреМодуля_DKC:ARTLEBEDEV_Бежевая:647596
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405904; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405904/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Белая, КНС_РамкаЧетыреМодуля_DKC:ARTLEBEDEV_Белая:647599
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400904; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400904/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Серая, КНС_РамкаЧетыреМодуля_DKC:ARTLEBEDEV_Серая:647600
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404904; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404904/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Черная, КНС_РамкаЧетыреМодуля_DKC:ARTLEBEDEV_Черная:647601
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402904; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402904/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Алюминий_Серая, КНС_РамкаЧетыреМодуля_DKC:Алюминий_Серая:647605
In: Этаж 01
Type - Material: DKC_Алюминий_Серый
Pset_BuildingElementProxyCommon - Reference: Алюминий_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404834; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404834/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – алюминий; • фактура – браш.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Алюминий_Черная, КНС_РамкаЧетыреМодуля_DKC:Алюминий_Черная:647607
In: Этаж 01
Type - Material: DKC_Алюминий_Черный
Pset_BuildingElementProxyCommon - Reference: Алюминий_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402834; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402834/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ Avanti (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – алюминий; • фактура – браш.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Дерево_Белая, КНС_РамкаЧетыреМодуля_DKC:Дерево_Белая:647611
In: Этаж 01
Type - Material: DKC_Дерево_Белый
Pset_BuildingElementProxyCommon - Reference: Дерево_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400844; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400844/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – беленый дуб.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Дерево_Черная, КНС_РамкаЧетыреМодуля_DKC:Дерево_Черная:647613
In: Этаж 01
Type - Material: DKC_Дерево_Черный
Pset_BuildingElementProxyCommon - Reference: Дерево_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402844; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402844/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – дерево венге.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Белая, КНС_РамкаЧетыреМодуля_DKC:Металл_Белая:647617
In: Этаж 01
Type - Material: DKC_Металл_Белый
Pset_BuildingElementProxyCommon - Reference: Металл_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400854; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400854/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Графитовая, КНС_РамкаЧетыреМодуля_DKC:Металл_Графитовая:647619
In: Этаж 01
Type - Material: DKC_Металл_Графит
Pset_BuildingElementProxyCommon - Reference: Металл_Графитовая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4407854; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4407854/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Золотая, КНС_РамкаЧетыреМодуля_DKC:Металл_Золотая:647622
In: Этаж 01
Type - Material: DKC_Металл_Золотой
Pset_BuildingElementProxyCommon - Reference: Металл_Золотая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4408854; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4408854/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Никилированная, КНС_РамкаЧетыреМодуля_DKC:Металл_Никилированная:647637
In: Этаж 01
Type - Material: DKC_Никель
Pset_BuildingElementProxyCommon - Reference: Металл_Никилированная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4409854; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4409854/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Темно-серая, КНС_РамкаЧетыреМодуля_DKC:Металл_Темно-серая:647625
In: Этаж 01
Type - Material: DKC_Металл_Серый
Pset_BuildingElementProxyCommon - Reference: Металл_Темно-серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4403854; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4403854/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Металл_Черная, КНС_РамкаЧетыреМодуля_DKC:Металл_Черная:647626
In: Этаж 01
Type - Material: DKC_Металл_Черный
Pset_BuildingElementProxyCommon - Reference: Металл_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402854; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402854/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан Luca Mertelli; • материал – металл; • покрытие – порошковая краска; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Белая, КНС_РамкаЧетыреМодуля_DKC:Натуральное стекло_Белая:647631
In: Этаж 01
Type - Material: DKC_Стекло_Белое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400824; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400824/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Светло-зеленая, КНС_РамкаЧетыреМодуля_DKC:Натуральное стекло_Светло-зеленая:647634
In: Этаж 01
Type - Material: DKC_Стекло_Зеленое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Светло-зеленая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4406824; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4406824/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Светло-серая, КНС_РамкаЧетыреМодуля_DKC:Натуральное стекло_Светло-серая:647635
In: Этаж 01
Type - Material: DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Светло-серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404824; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404824/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Черная, КНС_РамкаЧетыреМодуля_DKC:Натуральное стекло_Черная:647636
In: Этаж 01
Type - Material: DKC_Стекло_Черное
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402824; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402824/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
