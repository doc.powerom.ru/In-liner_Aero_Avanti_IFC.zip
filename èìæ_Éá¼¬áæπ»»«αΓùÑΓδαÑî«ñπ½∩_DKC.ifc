Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:24:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:24:30 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{441A8223-CFDA-4F08-86E5-350222DBBDA1}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:24:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:24:30 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:24:30 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Белая, КНС_РамкаСуппортЧетыреМодуля_DKC:Белая:686053
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400914; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400914/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000190; Описание: Назначение: • для монтажа ЭУИ в кабель-каналы и колонны. Характеристики: • материал – АБС-пластик; • устанавливается только на каркас 4402812 (он идет в комплекте в рамкой-суппортом).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Серая, КНС_РамкаСуппортЧетыреМодуля_DKC:Серая:686054
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404914; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404914/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000190; Описание: Назначение: • для монтажа ЭУИ в кабель-каналы и колонны. Характеристики: • материал – АБС-пластик; • устанавливается только на каркас 4402812 (он идет в комплекте в рамкой-суппортом).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Черная, КНС_РамкаСуппортЧетыреМодуля_DKC:Черная:686055
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402914; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402914/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000190; Описание: Назначение: • для монтажа ЭУИ в кабель-каналы и колонны. Характеристики: • материал – АБС-пластик; • устанавливается только на каркас 4402812 (он идет в комплекте в рамкой-суппортом).; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
