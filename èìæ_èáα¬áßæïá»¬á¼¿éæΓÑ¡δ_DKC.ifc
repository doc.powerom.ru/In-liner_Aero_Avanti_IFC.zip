Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:28:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:28:20 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{FD0D7A13-6822-49A3-A3C3-269E15C96884}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:28:20 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:28:20 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:28:20 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Алюминий, КНС_КаркасСЛапкамиВСтены_DKC:Алюминий:666526
In: Этаж 01
Type - Material: DKC_Алюминий_Бело-алюминиевый
Pset_BuildingElementProxyCommon - Reference: Алюминий
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400802; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400802/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000013; Описание: Назначение: Каркас для ЭУИ "Avanti" позволяет собрать модульное электроустановочное изделие для установки в стену. Каркас предназначен для изделий с двумя модулями. Распорные лапки обеспечивают надежную фиксацию изделия в стене. Каркас подходит как для горизонтально ориентированного монтажа, так и для вертикально ориентированного.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
