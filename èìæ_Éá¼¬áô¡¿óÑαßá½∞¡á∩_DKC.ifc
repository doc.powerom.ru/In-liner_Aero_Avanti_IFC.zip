Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:30:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:30:10 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{4E612135-8EA2-49F1-837F-BE82522CEC8D}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:30:10 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:30:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:30:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2 модуля_Серая, КНС_РамкаУниверсальная_DKC:2 модуля_Серая:645269
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 2 модуля_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F00011G; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F00011G/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: монтаж электроустановочных изделий серий "Viva" и типоразмер 45х45 мм в пластиковые короба "In-liner Front", алюминиевые короба и колонны "In-liner Aero", напольные башенки BUS.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 2 модуля_Черная, КНС_РамкаУниверсальная_DKC:2 модуля_Черная:645271
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F00011B; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F00011B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: монтаж электроустановочных изделий серий "Viva" и типоразмер 45х45 мм в пластиковые короба "In-liner Front", алюминиевые короба и колонны "In-liner Aero", напольные башенки BUS.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 4 модуля_Серая, КНС_РамкаУниверсальная_DKC:4 модуля_Серая:645274
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 4 модуля_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F00013G; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F00013G/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: монтаж электроустановочных изделий серий "Viva" и типоразмер 45х45 мм в пластиковые короба "In-liner Front", алюминиевые короба и колонны "In-liner Aero", напольные башенки BUS.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 4 модуля_Черная, КНС_РамкаУниверсальная_DKC:4 модуля_Черная:645279
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 4 модуля_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F00013B; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F00013B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: монтаж электроустановочных изделий серий "Viva" и типоразмер 45х45 мм в пластиковые короба "In-liner Front", алюминиевые короба и колонны "In-liner Aero", напольные башенки BUS.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 6 модулей_Серая, КНС_РамкаУниверсальная_DKC:6 модулей_Серая:645277
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 6 модулей_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F00015G; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F00015G/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: монтаж электроустановочных изделий серий "Viva" и типоразмер 45х45 мм в пластиковые короба "In-liner Front", алюминиевые короба и колонны "In-liner Aero", напольные башенки BUS.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 6 модулей_Черная, КНС_РамкаУниверсальная_DKC:6 модулей_Черная:645278
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 6 модулей_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: F00015B; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/F00015B/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: монтаж электроустановочных изделий серий "Viva" и типоразмер 45х45 мм в пластиковые короба "In-liner Front", алюминиевые короба и колонны "In-liner Aero", напольные башенки BUS.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны
