Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:45:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:45:11 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B61BCB04-54D0-4D9A-AFE8-BD77D37C674E}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:45:10 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:45:11 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:45:11 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: USB 2.0_Бежевая, КНС_USBРозеткаМодульная_DKC:USB 2.0_Бежевая:719769
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: USB 2.0_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405401; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405401/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 2.0_Белая, КНС_USBРозеткаМодульная_DKC:USB 2.0_Белая:719772
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: USB 2.0_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400401; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400401/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 2.0_Серая, КНС_USBРозеткаМодульная_DKC:USB 2.0_Серая:719773
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: USB 2.0_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404401; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404401/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 2.0_Черная, КНС_USBРозеткаМодульная_DKC:USB 2.0_Черная:719775
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: USB 2.0_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402401; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402401/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 3.0_Бежевая, КНС_USBРозеткаМодульная_DKC:USB 3.0_Бежевая:719780
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: USB 3.0_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405301/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 3.0_Белая, КНС_USBРозеткаМодульная_DKC:USB 3.0_Белая:719782
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: USB 3.0_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400301/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 3.0_Серая, КНС_USBРозеткаМодульная_DKC:USB 3.0_Серая:719783
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный, DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: USB 3.0_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404301/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: USB 3.0_Черная, КНС_USBРозеткаМодульная_DKC:USB 3.0_Черная:719785
In: Этаж 01
Type - Material: DKC_Стеклопластик, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: USB 3.0_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402301/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение HDMI и USB кабеля к рабочему месту. Характеристики: • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • для заделки контактов используется инструмент типа 110; • тип розетки – "А-А" или "мама-мама"; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары
