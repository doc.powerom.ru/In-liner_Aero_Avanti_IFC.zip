Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T12:53:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 12:53:47 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{E4E252B3-58C8-45A4-8D0F-3DF15B134170}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 12:53:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 12:53:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 12:53:47 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Алюминиевый кабель-канал_90х50/110х50/140х50_Цвет белый_DKC (2)
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Алюминиевый кабель-канал_90х50/110х50/140х50_Цвет белый_DKC
Name (Воздуховод прямоугольного сечения:КНС_Алюминиевый кабель-канал_90х50/110х50/140х50_Цвет белый_DKC:...)
533011
533121

# IfcFlowSegment: Воздуховод прямоугольного сечения:КНС_Алюминиевый кабель-канал_90х50/110х50/140х50_Цвет серебристый металлик_DKC, Воздуховод прямоугольного сечения:КНС_Алюминиевый кабель-канал_90х50/110х50/140х50_Цвет серебристый металлик_DKC:533133
In: Этаж 01
Pset_DistributionFlowElementCommon - Reference: КНС_Алюминиевый кабель-канал_90х50/110х50/140х50_Цвет серебристый металлик_DKC
