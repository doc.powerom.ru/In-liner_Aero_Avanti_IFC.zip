Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:37:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:37:05 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{57F8293E-F596-4EC5-9464-C5BFBA409E5D}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:37:04 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:37:04 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:37:04 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Бежевая, КНС_РозеткаТВФМСАТМодульная_DKC:Бежевая:794396
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Белый, DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405532; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405532/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение теле- и радиокабеля. Характеристики: • винтовые зажимы; • диапазон рабочих частот 4–2400 МГц; • затухание <1 дБ; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Белая, КНС_РозеткаТВФМСАТМодульная_DKC:Белая:794399
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400532; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400532/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение теле- и радиокабеля. Характеристики: • винтовые зажимы; • диапазон рабочих частот 4–2400 МГц; • затухание <1 дБ; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Серая, КНС_РозеткаТВФМСАТМодульная_DKC:Серая:794400
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404532; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404532/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение теле- и радиокабеля. Характеристики: • винтовые зажимы; • диапазон рабочих частот 4–2400 МГц; • затухание <1 дБ; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Черная, КНС_РозеткаТВФМСАТМодульная_DKC:Черная:794402
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Белый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402532; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402532/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000439; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение теле- и радиокабеля. Характеристики: • винтовые зажимы; • диапазон рабочих частот 4–2400 МГц; • затухание <1 дБ; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары
