Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:21:11
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:21:11 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{FAECF942-4B20-47D8-A0A9-C24E9499C354}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:21:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:21:10 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:21:10 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 5 кат двойная бежевая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная бежевая:683715
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405464; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405464/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная белая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная белая:683718
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400464; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400464/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная серая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная серая:683719
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404464; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404464/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная черная, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная черная:683721
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402464; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402464/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная экранированная бежевая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная экранированная бежевая:683726
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная экранированная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405364; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405364/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная экранированная белая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная экранированная белая:683728
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная экранированная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400364; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400364/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная экранированная серая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная экранированная серая:683729
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная экранированная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404364; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404364/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат двойная экранированная черная, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат двойная экранированная черная:683731
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 5 кат двойная экранированная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402364; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402364/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат одинарная бежевая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат одинарная бежевая:685675
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 5 кат одинарная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405463; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405463/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат одинарная белая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат одинарная белая:685676
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 5 кат одинарная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400463; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400463/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат одинарная серая, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат одинарная серая:685677
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 5 кат одинарная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404463; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404463/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 5 кат одинарная черная, КНС_РозеткаКомпьютернаяВСтену_DKC:5 кат одинарная черная:685678
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 5 кат одинарная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402463; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402463/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная бежевая, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная бежевая:685859
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405294; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405294/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная белая, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная белая:685860
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400294; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400294/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная серая, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная серая:685861
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404294; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404294/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная черная, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная черная:685862
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402294; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402294/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная экранированная бежевая, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная экранированная бежевая:685867
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная экранированная бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405394; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405394/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная экранированная белая, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная экранированная белая:685869
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная экранированная белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400394; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400394/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная экранированная серая, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная экранированная серая:685870
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная экранированная серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404394; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404394/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 6 кат двойная экранированная черная, КНС_РозеткаКомпьютернаяВСтену_DKC:6 кат двойная экранированная черная:685872
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 6 кат двойная экранированная черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402394; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402394/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение сетевого кабеля к рабочему месту. Характеристики: • 8P8C; • с пылезащитной шторкой; • с маркировочной табличкой; • в комплекте разъем Keystone; • заделка без инструмента.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
