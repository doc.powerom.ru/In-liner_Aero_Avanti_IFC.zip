Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-27T00:47:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Sep 27 00:47:50 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{B4CAF8F3-0EB7-4202-9D52-2097E1203E9F}\ifc * Database version: 5507 * Database creation date: Mon Sep 27 00:47:48 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Sep 27 00:47:48 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Sep 27 00:47:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2 модуля без винтов, КНС_КоробкаПодрозеточнаяДляСплошныхСтен_DKC:2 модуля без винтов:656647
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля без винтов
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 59302; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/59302/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC002601; Описание: Назначение • для монтажа розеток, выключателей, светорегуляторов и иных приборов на винтах или металлических захватах в кирпичные или бетонные стены. Особенности • материал – полипропилен; • температура монтажа от –5 до +100 °С; • двойная фиксация коробки за счет зацепов и соединительного "мостика"; • 6 отверстий для ввода кабеля от 10 до 25 мм; • нет необходимости срезать соединительный "мостик" при одинарном монтаже коробки; • соединительный "мостик" в комплекте; • диаметр коронки – 68 мм; • глубина коробки – 45 мм.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: 2 модуля с винтами, КНС_КоробкаПодрозеточнаяДляСплошныхСтен_DKC:2 модуля с винтами:656649
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля с винтами
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 59301; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/59301/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC002601; Описание: Назначение • для монтажа розеток, выключателей, светорегуляторов и иных приборов на винтах или металлических захватах в кирпичные или бетонные стены. Особенности • материал – полипропилен; • температура монтажа от –5 до +100 °С; • двойная фиксация коробки за счет зацепов и соединительного "мостика"; • 6 отверстий для ввода кабеля от 10 до 25 мм; • нет необходимости срезать соединительный "мостик" при одинарном монтаже коробки; • соединительный "мостик" в комплекте; • диаметр коронки – 68 мм; • глубина коробки – 45 мм.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
