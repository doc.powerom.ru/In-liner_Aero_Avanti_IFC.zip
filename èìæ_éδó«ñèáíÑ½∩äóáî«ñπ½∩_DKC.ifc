Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:35:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:35:31 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{8F5536BA-24F4-44BA-838A-2B5CBA3991D3}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:35:30 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:35:31 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:35:31 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Бежевый, КНС_ВыводКабеляДваМодуля_DKC:Бежевый:697679
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Бежевый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405982; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405982/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); для вывода и фиксации кабеля. Кол-во модулей: 2.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Белый, КНС_ВыводКабеляДваМодуля_DKC:Белый:697681
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400982; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400982/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); для вывода и фиксации кабеля. Кол-во модулей: 2.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Серый, КНС_ВыводКабеляДваМодуля_DKC:Серый:697682
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404982; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404982/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); для вывода и фиксации кабеля. Кол-во модулей: 2.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Черный, КНС_ВыводКабеляДваМодуля_DKC:Черный:697684
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402982; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402982/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000018; Описание: Назначение: для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); для вывода и фиксации кабеля. Кол-во модулей: 2.; Комментарии к типоразмеру: Модульные изделия, аксессуары
