Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:33:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:33:59 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{898887C9-FA7C-47D5-B1CB-47C6F0B7DF70}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:33:58 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:33:59 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:33:59 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: ARTLEBEDEV_Бежевая, КНС_РамкаВосемьМодулей_DKC:ARTLEBEDEV_Бежевая:650824
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405908; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405908/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Белая, КНС_РамкаВосемьМодулей_DKC:ARTLEBEDEV_Белая:650827
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400908; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400908/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Серая, КНС_РамкаВосемьМодулей_DKC:ARTLEBEDEV_Серая:650828
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404908; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404908/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: ARTLEBEDEV_Черная, КНС_РамкаВосемьМодулей_DKC:ARTLEBEDEV_Черная:650829
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: ARTLEBEDEV_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402908; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402908/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • промышленный дизайн создан в Студии Артемия Лебедева; • материал – УФ-стойкий пластик.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Белая, КНС_РамкаВосемьМодулей_DKC:Натуральное стекло_Белая:650859
In: Этаж 01
Type - Material: DKC_Стекло_Белое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400828; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400828/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Светло-зеленая, КНС_РамкаВосемьМодулей_DKC:Натуральное стекло_Светло-зеленая:650862
In: Этаж 01
Type - Material: DKC_Стекло_Зеленое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Светло-зеленая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4406828; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4406828/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Светло-серая, КНС_РамкаВосемьМодулей_DKC:Натуральное стекло_Светло-серая:650863
In: Этаж 01
Type - Material: DKC_Стекло_Серое
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Светло-серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404828; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404828/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ

# IfcBuildingElementProxy: Натуральное стекло_Черная, КНС_РамкаВосемьМодулей_DKC:Натуральное стекло_Черная:650864
In: Этаж 01
Type - Material: DKC_Стекло_Черное
Pset_BuildingElementProxyCommon - Reference: Натуральное стекло_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402828; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402828/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000007; Описание: Назначение: • декоративное оформление серии "Avanti"; • монтаж в стену на каркас ЭУИ "Avanti" (код 4400802). Характеристики: • дизайн разработан B. Dall’Ecco; • материал – стекло; • фактура – глянец; • температура монтажа от –5 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
