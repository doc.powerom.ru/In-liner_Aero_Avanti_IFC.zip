Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:30:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:30:40 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{4E8C960B-91D3-457B-A466-5AB45AC9C653}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:30:39 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:30:39 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:30:39 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 2P+E 16А 230В_Бежевая, КНС_РозеткаМодульная_DKC:2P+E 16А 230В_Бежевая:547842
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2P+E 16А 230В_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2P+E 16А 230В_Белая, КНС_РозеткаМодульная_DKC:2P+E 16А 230В_Белая:547845
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2P+E 16А 230В_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2P+E 16А 230В_Красная, КНС_РозеткаМодульная_DKC:2P+E 16А 230В_Красная:547846
In: Этаж 01
Type - Material: DKC_Пластик_Красный, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2P+E 16А 230В_Красная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4401002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4401002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2P+E 16А 230В_Серая, КНС_РозеткаМодульная_DKC:2P+E 16А 230В_Серая:547847
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2P+E 16А 230В_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2P+E 16А 230В_Черная, КНС_РозеткаМодульная_DKC:2P+E 16А 230В_Черная:547849
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2P+E 16А 230В_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402002; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402002/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: С крышкой_2P+E 16А 230В_Бежевая, КНС_РозеткаМодульная_DKC:С крышкой_2P+E 16А 230В_Бежевая:547853
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E 16А 230В_Бежевая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405012; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405012/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: С крышкой_2P+E 16А 230В_Белая, КНС_РозеткаМодульная_DKC:С крышкой_2P+E 16А 230В_Белая:547856
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E 16А 230В_Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400012; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400012/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: С крышкой_2P+E 16А 230В_Серая, КНС_РозеткаМодульная_DKC:С крышкой_2P+E 16А 230В_Серая:547857
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E 16А 230В_Серая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404012; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404012/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: С крышкой_2P+E 16А 230В_Черная, КНС_РозеткаМодульная_DKC:С крышкой_2P+E 16А 230В_Черная:547858
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: С крышкой_2P+E 16А 230В_Черная
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402012; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402012/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000125; Описание: Назначение: • для монтажа в подрозеточные коробки глубиной не менее 45 мм (код 59301); • подключение оргтехники, бытовых приборов и т. д. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • защитные шторки; • фиксация в подрозеточную коробку при помощи саморезов; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; Комментарии к типоразмеру: Модульные изделия, аксессуары
