Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:23:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:23:25 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{668240A3-91B1-4F2C-B73F-3F6D31D7C161}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:23:25 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:23:25 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:23:25 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Белая, КНС_РамкаДляМонтажаВСтенуДваМодуля_DKC:Белая:690327
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Стеклопластик
Pset_BuildingElementProxyCommon - Reference: Белая
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400922; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400922/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000080; Описание: Назначение: • для монтажа в стены; • для создания пыле- и влагозащищенных решений. Характеристики: • материал – полипропилен; A • температура монтажа от –25 до +60 °С.; Комментарии к типоразмеру: Avanti - универсальная серия ЭУИ
