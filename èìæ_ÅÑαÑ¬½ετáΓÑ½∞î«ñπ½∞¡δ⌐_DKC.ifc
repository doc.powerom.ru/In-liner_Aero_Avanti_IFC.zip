Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:36:01
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:36:01 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{82547F4C-6F88-4AA8-A801-AEF21B1BD73E}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:36:00 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:36:01 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:36:01 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 1 модуль_Бежевый, КНС_ПереключательМодульный_DKC:1 модуль_Бежевый:700363
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 1 модуль_Бежевый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405111; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405111/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 1 модуль_Белый, КНС_ПереключательМодульный_DKC:1 модуль_Белый:700366
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 1 модуль_Белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400111; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400111/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 1 модуль_Серый, КНС_ПереключательМодульный_DKC:1 модуль_Серый:700367
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 1 модуль_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404111; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404111/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 1 модуль_Черный, КНС_ПереключательМодульный_DKC:1 модуль_Черный:700369
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 1 модуль_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402111; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402111/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2 модуля_Бежевый, КНС_ПереключательМодульный_DKC:2 модуля_Бежевый:700374
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля_Бежевый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405112; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405112/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2 модуля_Белый, КНС_ПереключательМодульный_DKC:2 модуля_Белый:700376
In: Этаж 01
Type - Material: DKC_Пластик_Белый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля_Белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400112; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400112/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2 модуля_Серый, КНС_ПереключательМодульный_DKC:2 модуля_Серый:700377
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля_Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404112; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404112/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: 2 модуля_Черный, КНС_ПереключательМодульный_DKC:2 модуля_Черный:700379
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 2 модуля_Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402112; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402112/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001590; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • включение/выключение освещения с двух мест. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм (по 2 отверстия на одну клемму); • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • номинальный ток – 16 A; • номинальное напряжение – 230 В; • фиксация в подрозеточные коробки при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары
