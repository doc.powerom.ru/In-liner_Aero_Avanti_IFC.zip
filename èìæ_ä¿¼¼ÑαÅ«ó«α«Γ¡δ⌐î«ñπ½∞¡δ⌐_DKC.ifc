Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T23:28:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 23:28:54 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{32180C5E-A202-4291-A032-B9C45FFDC0FA}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 23:28:53 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 23:28:53 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 23:28:53 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: Бежевый, КНС_ДиммерПоворотныйМодульный_DKC:Бежевый:705301
In: Этаж 01
Type - Material: DKC_Пластик_Бежевый, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Бежевый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4405131; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4405131/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • управление освещением помещения; • регулирование 60–800 Вт для ламп накаливания и галогенных ламп. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • встроенная подсветка; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Белый, КНС_ДиммерПоворотныйМодульный_DKC:Белый:705304
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4400131; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4400131/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • управление освещением помещения; • регулирование 60–800 Вт для ламп накаливания и галогенных ламп. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • встроенная подсветка; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Серый, КНС_ДиммерПоворотныйМодульный_DKC:Серый:705305
In: Этаж 01
Type - Material: DKC_Пластик_Серый, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Серый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4404131; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4404131/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • управление освещением помещения; • регулирование 60–800 Вт для ламп накаливания и галогенных ламп. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • встроенная подсветка; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары

# IfcBuildingElementProxy: Черный, КНС_ДиммерПоворотныйМодульный_DKC:Черный:705307
In: Этаж 01
Type - Material: DKC_Пластик_Черный, DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: Черный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 4402131; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/4402131/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC000025; Описание: Назначение: • для монтажа в системы "In-liner Front" и "In-liner Aero" при помощи рамок-суппортов и каркасов "Avanti" (код 4400912 и т.д.); • управление освещением помещения; • регулирование 60–800 Вт для ламп накаливания и галогенных ламп. Характеристики: • диаметр отверстий для ввода кабелей – 3 мм; • винтовые зажимы; • шаблон для зачистки кабеля – 11 мм; • встроенная подсветка; • фиксация в подрозеточные коробки глубиной не менее 45 мм при помощи каркаса с лапками (код 4400802) и саморезов.; Комментарии к типоразмеру: Модульные изделия, аксессуары
