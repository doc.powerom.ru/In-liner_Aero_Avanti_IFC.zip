Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-09-25T13:29:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Alternate UI 19.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Sep 25 13:29:33 2021 * Host: Best-Komp * Database: C:\Users\Admin\AppData\Local\Temp\{F7D7C04F-DE3D-455C-B621-B0EF51CE5808}\ifc * Database version: 5507 * Database creation date: Sat Sep 25 13:29:31 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Sep 25 13:29:32 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Sep 25 13:29:32 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 55, 44, 59, 999999; RefLongitude: 37, 42, 0, 2746; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm

# IfcBuildingElementProxy: 09571_2.7 - 4.25м_цвет светло-серебристый металлик, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09571_2.7 - 4.25м_цвет светло-серебристый металлик:644120
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 09571_2.7 - 4.25м_цвет светло-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09571; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09571/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09572_2.7 - 4.25м_цвет белый, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09572_2.7 - 4.25м_цвет белый:644121
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 09572_2.7 - 4.25м_цвет белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09572; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09572/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09573_2.7 - 4.25м_цвет чёрный, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09573_2.7 - 4.25м_цвет чёрный:644122
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 09573_2.7 - 4.25м_цвет чёрный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09573; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09573/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09574_2.7 - 4.25м_цвет темно-серебристый металлик, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09574_2.7 - 4.25м_цвет темно-серебристый металлик:644123
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 09574_2.7 - 4.25м_цвет темно-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09574; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09574/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09581_1.5 - 3м_цвет светло-серебристый металлик, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09581_1.5 - 3м_цвет светло-серебристый металлик:642283
In: Этаж 01
Type - Material: DKC_Пластик_Светло-серый
Pset_BuildingElementProxyCommon - Reference: 09581_1.5 - 3м_цвет светло-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09581; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09581/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09582_1.5 - 3м_цвет белый, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09582_1.5 - 3м_цвет белый:642285
In: Этаж 01
Type - Material: DKC_Пластик_Белый
Pset_BuildingElementProxyCommon - Reference: 09582_1.5 - 3м_цвет белый
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09582; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09582/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09583_1.5 - 3м_цвет чёрный, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09583_1.5 - 3м_цвет чёрный:642286
In: Этаж 01
Type - Material: DKC_Пластик_Черный
Pset_BuildingElementProxyCommon - Reference: 09583_1.5 - 3м_цвет чёрный
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09583; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09583/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны

# IfcBuildingElementProxy: 09584_1.5 - 3м_цвет темно-серебристый металлик, КНС_КолоннаТелескопическая_1.5-4.25_DKC:09584_1.5 - 3м_цвет темно-серебристый металлик:642287
In: Этаж 01
Type - Material: DKC_Пластик_Серый
Pset_BuildingElementProxyCommon - Reference: 09584_1.5 - 3м_цвет темно-серебристый металлик
Pset_ManufacturerTypeInformation - Manufacturer: DKC
Pset_SpaceHeaterTypeCommon - ADSK_Единица измерения: шт.; ADSK_Код изделия: 09584; ADSK_URL документации изделия: https://www.dkc.ru/ru/support/media/kabelenesushchie-sistemy/; ADSK_URL страницы изделия: https://www.dkc.ru/ru/catalog/37/09584/; ADSK_Версия Revit: 2019; BL_BIM library: https://bimlib.pro/manufacturer/company/14890; BL_Email: support@dkc.ru; URL: https://www.dkc.ru/; Категория: Электрические приборы; ETIM Article Class: EC001941; Описание: Назначение: • организация рабочих мест в помещениях, где рабочее место находится далеко от стен. Условия монтажа: • колонна крепится к полу в 4 точках и к потолку в 4 точках. При установке сквозь фальшпотолок колонна 4,25 м может крепиться к потолку высотой до 4,55 м, а колонна 3,05 м – к потолку высотой до 3,25 м. При этом потолочные декоративные накладки переставляются к фальшпотолку, скрывая щель вокруг колонны; • подвод кабелей к колонне – с помощью гофрированных труб (по полу или потолку) или в напольном кабель-канале ДКС. Верхняя часть колонны – полая, имеет внешний габаритный размер 65х65 мм, достаточный для спуска кабелей в нижнюю электроустановочную часть; • монтаж ЭУИ осуществляется при помощи каркасов и рамок, которые используются в коробах "In-liner Aero", "In-liner Front". Колонны рекомендуется заземлять.; Комментарии к типоразмеру: In-liner Aero - алюминиевые кабельные короба и колонны
